## config/boards/shields/kumikokeynum/Kconfig.defconfig
```kconfig
if SHIELD_KUMIKOKEYNUM

config ZMK_KEYBOARD_NAME
    default "KumikoKey Numpad"

endif
```
